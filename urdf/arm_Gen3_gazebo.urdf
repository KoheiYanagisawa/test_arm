Commit message: gazebo用にいろいろ追加

File: urdf/arm_Gen3_gazebo.urdf (robot description, URDF)
Before this commit: robot test_robot, 8 links, 7 joints
Links:
- added link world
Joints:
- added joint base_joint: type fixed, parent world, child base_link
